/*Si scriva un programma C che definisca una struttura che permetta di contenere una serie di dati (struct squadra ) del tipo: - nome squadra (stringa di lunghezza 20);
• codice squadra (intero);
• goal fatti (intero);
• goal subiti (intero).
Li si memorizzi in un vettore di strutture "squadre";
• Stampi a terminale tutti i nomi e codici delle squadre che hanno fatto un numero di goal maggiore del numero dei goal subiti.
• Letto a terminale un codice di una squadra stampi a video il nome della squadra, i goal fatti e i goal subiti.*/

#include <stdio.h>
#include <string.h>

typedef struct squadra{
  char nomeSquadra[20];
  int codSquadra;
  int goalFatti;
  int goalSubiti;
}squadra;

//HEADER FUNZIONI
int inserisciSquadra(squadra sq[100], int cont);
void stampaSquadre(squadra sq[100], int cont);
void cercaSquadra(squadra sq[100], int cont);

int main()
{
  squadra squadre[100];  
  int numSquadre = 0;
  int r;
  //Menu
  do{
    printf("Menu\n\n");
    printf("1) Inserisci squadra\n2) Stampa squadra\n3) Ricerca squadra\n4) Esci\n\n>> ");
    scanf("%d",&r);
    switch(r){
      case 1:
        numSquadre = inserisciSquadra(squadre,numSquadre);
        break;
      case 2:
        stampaSquadre(squadre,numSquadre);
        break;
      case 3:
        cercaSquadra(squadre,numSquadre);
        break;
      
    }
  }while (r!=4);
  return 0;
}

int inserisciSquadra(squadra sq[100], int cont){
  printf("Inserisci nome squadra: ");
    fflush(stdin); //Quando la lettura di caratteri o stringhe salta, questa riga risolve il problema. su mac, fflush(stdin) diventa fpurge(stdin); su repl.it diventa __fpurge(stdin);
  gets(sq[cont].nomeSquadra);
  printf("Inserisci codice squadra: ");
  scanf("%d",&sq[cont].codSquadra);
  printf("Inserisci goal fatti: ");
  scanf("%d",&sq[cont].goalFatti);
  printf("Inserisci goal subiti: ");
  scanf("%d",&sq[cont].goalSubiti);
  cont ++;  
  return cont;
}

void stampaSquadre(squadra sq[100], int cont){
  printf("Le squadre che hanno fatto più goal di quelli subiti sono:\n");
  for (int i=0; i<cont; i++)
  {
    if(sq[i].goalFatti>sq[i].goalSubiti)
      printf("%s\n",sq[i].nomeSquadra);
  }
}

void cercaSquadra(squadra sq[100], int cont){
  int cod;
  printf("Inserisci codice squadra: ");
  scanf("%d",&cod);
  for (int i=0; i<cont; i++)
  {
    if(sq[i].codSquadra==cod){
      printf("Nome squadra: %s ",sq[i].nomeSquadra);
      printf("Goal fatti:%d ",sq[i].goalFatti);
      printf("Goal subiti: %d\n",sq[i].goalSubiti);
    }
  }
}
